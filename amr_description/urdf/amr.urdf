Commit message: 05/04

File: amr_description/urdf/amr.urdf (robot description, URDF)
Before this commit: robot amr, 12 links, 11 joints
Joints:
- joint hokuyo_joint: origin xyz=0.40 0.25 0.2 rpy=0 0  0.7853 -> xyz=0.332 -0.260 0.0 rpy=0.0 0.0 0.785
